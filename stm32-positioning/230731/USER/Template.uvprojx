# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLib\inc;..\HARDWARE\delay;..\HARDWARE\sys;..\HARDWARE\CAN;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\OUTPUT;..\HARDWARE\systime;..\HARDWARE\TIMER;..\HARDWARE\WDG;..\HARDWARE\buzzer;..\HARDWARE\main;..\HARDWARE\uart;..\HARDWARE\PWM;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\SPI;..\HARDWARE\PID;..\HARDWARE\IO;..\VL53L1X;..\VL53L1X\core;..\VL53L1X\demo;..\VL53L1X\platform
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/buzzer/: buzzer.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OUTPUT/: output.c
    ../HARDWARE/sys/: sys.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/uart/: uart.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/IO/: io.c
    ./: kalanman.c kalanman.h encoder.c encoder.h
